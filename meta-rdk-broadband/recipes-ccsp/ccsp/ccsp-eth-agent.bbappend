require ccsp_common_rpi.inc
CFLAGS_aarch64_append = " -Werror=format-truncation=1 "
