CFLAGS_append_aarch64 = " -D_64BIT_ARCH_SUPPORT_ "
