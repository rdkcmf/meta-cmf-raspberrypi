LDFLAGS_aarch64 += " -lutctx -lprivilege "
