CFLAGS += "-UENABLE_READ_DELAY"
CFLAGS += " -DREF_PLATFORM"
