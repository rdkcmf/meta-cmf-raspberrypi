CFLAGS += " -lds-hal -DHAS_FLASH_PERSISTENT"
