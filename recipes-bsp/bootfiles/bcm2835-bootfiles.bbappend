RPIFW_DATE = "20180619"
SRCREV = "748fb17992426bb29d99224b93cb962fefbdc833"

SRC_URI[md5sum] = "6c7ff9536cee52253e5fbe54ad963a8b"
SRC_URI[sha256sum] = "e657478923220947321503ef980f3a6772d6f1e11b48c5c359bdb5e3d49355d9"
