require ccsp_common_rpi.inc

LDFLAGS_append = " -Wl,--no-as-needed"
