DEPENDS_aarch64 += " libunpriv"
LDFLAGS_aarch64 += " -lutctx -lprivilege "
