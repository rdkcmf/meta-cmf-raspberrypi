COMPATIBLE_HOST = '(x86_64|i.86|powerpc|powerpc64|aarch64|arm|mips).*-linux'
