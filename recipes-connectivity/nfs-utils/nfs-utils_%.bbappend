CFLAGS_append = " \
    -I${STAGING_INCDIR}/libevent \
"
