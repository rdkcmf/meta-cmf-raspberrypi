DEPENDS += " nanomsg"
