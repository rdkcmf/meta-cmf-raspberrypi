IMAGE_INSTALL_remove = " libgcov-dev"

IMAGE_ROOTFS_SIZE = "14192"
