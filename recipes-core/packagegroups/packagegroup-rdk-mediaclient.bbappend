RDEPENDS_packagegroup-rdk-generic-mediaclient_remove_rpi = "\
    qtwebkit \
    rdkbrowser \
"
