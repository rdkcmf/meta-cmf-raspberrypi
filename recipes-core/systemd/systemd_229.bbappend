PACKAGECONFIG_append = " resolved"
