FILESEXTRAPATHS_prepend := "${THISDIR}/breakpad:"

SRC_URI += " \
           file://0006-fix-to-compile-breakpad-using-sdk.patch \
"

