do_install_append_broadband() {
   rm ${D}${localstatedir}/lib/logrotate.status
}
