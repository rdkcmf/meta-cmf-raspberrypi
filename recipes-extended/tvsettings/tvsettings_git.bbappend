DEPENDS_remove = "hdmicec"
DEPENDS_append = " hdmicecheader"
