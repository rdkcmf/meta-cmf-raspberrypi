PROVIDES = "virtual/westeros-soc westeros-soc"
RPROVIDES_${PN} = "virtual/westeros-soc westeros-soc"
