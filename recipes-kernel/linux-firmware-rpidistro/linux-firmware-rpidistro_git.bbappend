SRC_URI_remove = "git://github.com/RPi-Distro/firmware-nonfree"
SRC_URI += "git://github.com/RPi-Distro/firmware-nonfree;branch=buster;protocol=https"
