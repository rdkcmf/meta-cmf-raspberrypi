SRC_URI_remove = "git://github.com/raspberrypi/linux.git;branch=rpi-4.14.y"
SRC_URI += "git://github.com/raspberrypi/linux.git;protocol=https;branch=rpi-4.14.y"
