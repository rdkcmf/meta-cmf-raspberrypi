# lame is not required for RDK build and it has restricted licensing
PACKAGECONFIG_remove = "lame mpeg2dec"