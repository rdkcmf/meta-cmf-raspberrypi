DEPENDS_remove_dunfell = "virtual/kernel bridge-utils"
DEPENDS_append_class-target_dunfell = " virtual/kernel"
DEPENDS_append_class-target_dunfell = " bridge-utils"

