FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "\
            file://GMP_add_aarch64_support.patch \
"
