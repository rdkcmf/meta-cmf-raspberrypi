FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "\
            file://0001-Nettle-add-aarch64-support.patch \
"
