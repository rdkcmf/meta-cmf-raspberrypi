
CXXFLAGS_append_camera += "-Wa,-mimplicit-it=thumb"
