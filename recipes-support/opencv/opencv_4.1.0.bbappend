
PACKAGECONFIG_remove = "gstreamer"
